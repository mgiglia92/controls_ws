Commit message: crude p control

File: testing/myblock.urdf (robot description, URDF)
Before this commit: robot block_2, 1 links, 0 joints
Links:
- link block_2_base_link: mass 0.02 -> 1; geometry collision box size=1 1 1; visual box size=1 1 1
